# Keil uVision project main.uvprojx, settings and files
target Do Tan So Cua Tin Hieu (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\FWlib\Include;.\Main;.\Device\Include;.\User\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start Up
    ./Startup/CM3/: core_cm3.c system_stm32f10x.c
    ./Startup/: startup_stm32f10x_md.s
  group FWLib
    ./FWlib/Source C/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c misc.c stm32f10x_usart.c
  group User
    ./User/Source C/: user_delay.c user_gpio.c user_timer.c user_interrupt.c user_nvic.c user_usart.c
  group Main
    ./Main/: main.c
software components: CMSIS:CORE 5.1.1
